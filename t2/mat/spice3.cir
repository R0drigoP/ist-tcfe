R1 1 2 1040.053942
R2 2 3 2071.468240
R3 2 5 3060.156941
R4 0 5 4137.507283
R5 5 6 3132.054677
R6 9 7 2010.656370
R7 7 8 1003.187580
Vs 1 0 0V
V0 0 9 0V
Hd 5 8 V0 8349.560578
Gb 6 3 (2,5) 0.007049
C1 6 8 0.000001
.ic V(6)=8.554673 V(8)=0.000000
